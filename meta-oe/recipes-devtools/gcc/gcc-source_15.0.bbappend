FILESEXTRAPATHS:prepend := "${THISDIR}/gcc-15.0:"

SRC_URI:append = " file://0005-optional-libstdc.patch"
