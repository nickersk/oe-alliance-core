SRC_URI = "git://github.com/FluidSynth/fluidsynth.git;branch=master;protocol=https"
SRCREV = "4d8fe638e1a48660a4c843d493f69a86579e12f0"
PV = "2.3.2"
